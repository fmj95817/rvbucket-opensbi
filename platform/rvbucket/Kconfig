## platform/rvbucket/Kconfig
```kconfig
# SPDX-License-Identifier: BSD-2-Clause

config PLATFORM_RVBUCKET
	bool
	select IPI_MSWI
	select IRQCHIP_PLIC
	select TIMER_MTIMER
	default y
```
